<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DIO-PORT_Drivers.ewp</path>
    </project>
    <batchBuild />
</workspace>
