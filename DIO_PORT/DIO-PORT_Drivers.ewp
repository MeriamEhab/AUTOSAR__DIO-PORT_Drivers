# IAR project DIO-PORT_Drivers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../AUTOSAR/AUTOSAR_Project/: Common_Macros.h Compiler.h cstartup_M.c Det.c Det.h Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h Platform_Types.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h Std_Types.h tm4c123gh6pm_registers.h
    ./: main.c
